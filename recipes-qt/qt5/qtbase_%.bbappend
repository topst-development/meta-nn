PACKAGECONFIG:append = " linuxfb accessibility fontconfig libinput" 
PACKAGECONFIG:remove = " examples tests gbm eglfs gl gles2 kms"
