RDEPENDS:${PN} += " \
	packagegroup-nn-toolchain-target \
"
