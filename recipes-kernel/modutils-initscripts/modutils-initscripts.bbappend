INITSCRIPT_PARAMS = "start 07 S ."
