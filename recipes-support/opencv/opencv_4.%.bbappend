PACKAGECONFIG:remove = "gstreamer"
EXTRA_OECMAKE += "-DWITH_OPENMP=ON"