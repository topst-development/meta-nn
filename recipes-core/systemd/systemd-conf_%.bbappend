FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
# SRC_URI += "file://eth.network"
