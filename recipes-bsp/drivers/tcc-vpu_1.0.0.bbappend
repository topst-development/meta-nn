FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

#SRCREV = "3f91f5fb95f727b2429e68f2e9895d8d14b2f85a"

#SRC_URI:remove = "${TELECHIPS_AUTOMOTIVE_BSP_GIT}/vpu/vpu-kernel-library.git;protocol=${ALS_GIT_PROTOCOL};branch=${ALS_BRANCH}"
#SRC_URI:prepend = "${TELECHIPS_AUTOMOTIVE_BSP_GIT}/vpu-kernel-library.git;protocol=${ALS_GIT_PROTOCOL};branch=${ALS_BRANCH} "
