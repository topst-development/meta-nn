FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

LIC_FILES_CHKSUM = "file://Licenses/README;md5=5a7450c57ffe5ae63fd732446b988025"

#SRCREV = "047f197054e3edadac39534fec27a74ac89af495"
#SRC_URI += ""
