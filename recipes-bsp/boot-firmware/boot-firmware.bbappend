FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/${CHIP_PATH}:"
#ALS_BRANCH:tcc750x = "tcc750x"
#SRCREV:tcc750x = "8afc1e3ae96a89bb5ac588f942f2d7e5c39f6fef"
